# Keil uVision project USB2CAN.uvproj, settings and files
target STM32F103B (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template
  c flags: Optim=1
  c define: VECT_TAB_FLASH
  c include: ..\Source;..\library\inc;..\Project
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../Source/: main.c Tasks.c USB2CAN_Func.c
  group RL-ARM
    ../Source/: RTX_CAN.c RTX_Config.c CAN_Hw.c
  group User_Driver
    ../Source/: CQueue.c USB2CAN_BSL.c USART.c Flash.c
  group FWLib
    ../library/Lib/: STM32F10xR.LIB STM32F10xD.LIB
  group RVMDK
    ../Source/: STM32F10x.s
  group Doc
    ./: readme.txt
